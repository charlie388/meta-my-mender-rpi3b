FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_mender-uboot = " file://0005-add-bootargs.patch "
